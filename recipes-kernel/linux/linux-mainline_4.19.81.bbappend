FILESEXTRAPATHS_prepend := "${THISDIR}/patchs:"

SRC_URI += "file://0001-uart1-uart2-dts-patch.patch \
       "

